options:
  parameters:
    author: LoRa Concentrator
    description: LoRa Concentrator Example Flowgraph
    generate_options: qt_gui
    id: concentrator_example
    output_language: python
    title: LoRa Concentrator Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: int(samp_rate/channel_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 125000/2*1.2, 125000*0.2)
    type: ccc
  states: {}
- name: lora_concentrator_channel_sensor_0
  id: lora_concentrator_channel_sensor
  parameters:
    channel_freq: '868100000'
    channel_index: '0'
    energy_threshold_db: '-100.0'
    samp_rate: channel_rate
    window_size_ms: '100'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: '868100000'
    impl_head: 'False'
    os_factor: int(channel_rate/125000)
    preamb_len: '8'
    sf: '7'
    sync_word: '[0x34]'
  states: {}
- name: lora_concentrator_metadata_extractor_0
  id: lora_concentrator_metadata_extractor
  parameters:
    bw: '125000'
    channel_freq: '868100000'
    channel_index: '0'
    gateway_id: '"gw-test-01"'
    sf: '7'
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    out_sig: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    out_sig: 'True'
    print_rx_msg: 'True'
  states: {}
- name: lora_concentrator_mqtt_sink_0
  id: lora_concentrator_mqtt_sink
  parameters:
    broker_host: '"localhost"'
    broker_port: '1883'
    ca_cert_path: '""'
    client_id: '"gw-001-pub"'
    gateway_id: '"gw-001"'
    password: '""'
    qos: '1'
    tls_enabled: 'False'
    username: '""'
  states: {}
- name: lora_concentrator_mqtt_source_0
  id: lora_concentrator_mqtt_source
  parameters:
    broker_host: '"localhost"'
    broker_port: '1883'
    ca_cert_path: '""'
    client_id: '"gw-001-sub"'
    gateway_id: '"gw-001"'
    password: '""'
    qos: '1'
    tls_enabled: 'False'
    username: '""'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_concentrator_channel_sensor_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_concentrator_metadata_extractor_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_crc_verif_0, msg, lora_concentrator_mqtt_sink_0, rx_payload]
- [lora_concentrator_metadata_extractor_0, metadata, lora_concentrator_mqtt_sink_0, rx_metadata]
- [lora_concentrator_channel_sensor_0, sensing, lora_concentrator_mqtt_sink_0, sensing]
- [lora_concentrator_mqtt_source_0, tx_request, blocks_message_debug_0, print]

metadata:
  file_format: 1
